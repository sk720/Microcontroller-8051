# Keil uVision project addin.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8XC52 NXP
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: addin +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./demoproj/: addition.asm
